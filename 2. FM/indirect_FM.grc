options:
  parameters:
    author: luso
    generate_options: qt_gui
    id: indirect_FM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: chooser
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1
    label0: Cos
    label1: Random Source
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: real
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: Frequency
    start: '0'
    step: '10'
    stop: '10000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '1'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: int
  states: {}
- name: analog_random_uniform_source_x_1
  id: analog_random_uniform_source_x
  parameters:
    maximum: '1'
    minimum: '0'
    seed: '0'
    type: int
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1, -1]'
    fftaps: '1'
    type: ffd
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: round(samp_rate/freq)
    srate: samp_rate
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1'
    type: float
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_int_to_float_0, '0']
- [analog_random_uniform_source_x_1, '0', blocks_int_to_float_0_0, '0']
- [blocks_int_to_float_0, '0', blocks_selector_0, '1']
- [blocks_int_to_float_0_0, '0', blocks_selector_0, '0']
- [blocks_selector_0, '0', single_pole_iir_filter_xx_0, '0']
- [iir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [iir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [single_pole_iir_filter_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [single_pole_iir_filter_xx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
