options:
  parameters:
    author: luso
    generate_options: qt_gui
    id: digital_PCM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '.1'
    stop: '1'
    value: '0.001'
    widget: dial
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: gain
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '128'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\Downloads\aibecam.mp3
    repeat: 'False'
    type: float
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '128'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__ will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          def __init__(self, mu=255):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='u-law Compresser',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.ry = 0
              self.mu = mu

          def work(self, input_items, output_items):
              #buf = [0] * len(input_items[0])
              a0 = np.log10(1 + self.mu*np.abs(input_items))*np.sign(input_items)
              b0 = np.log10(1+self.mu)
       
              output_items[0][:] = a0 / b0
              # Return the length of the output items produced
      	
              return len(output_items[0])
    mu: '255'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class ulaw_decoder(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          def __init__(self, mu=255):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='u-law Expander',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.mu = mu

          def work(self, input_items, output_items):
              # Ensure input_items is properly indexed
              c0 = np.sign(input_items[0]) * (1/self.mu) * ((1 + self.mu)**np.abs(input_items[0]) - 1)
              output_items[0][:] = c0

              # Return the length of the output items produced
              return len(output_items[0])
    mu: '255'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: out
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: decode
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: ulaw
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: out
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: out
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: ulaw
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: ulaw
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: ulaw
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [audio_source_0, '0', epy_block_0, '0']
- [audio_source_0, '0', virtual_sink_0, '0']
- [blocks_add_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_add_xx_0, '0', epy_block_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_xx_0, '0']
- [blocks_file_source_0, '0', epy_block_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_float_to_char_0, '0', blocks_char_to_float_0, '0']
- [epy_block_0, '0', blocks_float_to_char_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0_0, '0', low_pass_filter_0, '0']
- [epy_block_0_0, '0', virtual_sink_1, '0']
- [low_pass_filter_0, '0', virtual_sink_2, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_0, '0', qtgui_time_sink_x_1, '0']
- [virtual_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_1, '0', qtgui_time_sink_x_1, '1']
- [virtual_source_1_0, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_2, '0', blocks_add_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
