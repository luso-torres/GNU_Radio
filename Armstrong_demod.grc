options:
  parameters:
    generate_options: qt_gui
    id: Armstrong
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: Amplitude
    min_len: '20'
    start: '0'
    step: '.1'
    stop: '1'
    value: '1'
  states: {}
- name: df
  id: variable_qtgui_range
  parameters:
    label: Frequency Deviation
    start: '0'
    step: '1'
    stop: '75000'
    value: '75000'
    widget: eng
  states: {}
- name: f_c
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: f_lo
  id: variable_qtgui_entry
  parameters:
    label: Frequency Local Oscillator
    type: int
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    label: Frequency
    min_len: '20'
    start: '1000'
    step: '1000'
    stop: '10000'
    value: '10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: 2* np.pi *df/samp_rate
    min_freq: 2* np.pi *df/samp_rate
    w: 2 * np.pi * 1
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: np.pi
    min_freq: '-np.pi'
    w: np.pi/10
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f_c
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f_c
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: amp
    comment: FM Signal
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f_lo
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '2'
    high_cutoff_freq: 3*f_c+df
    low_cutoff_freq: 3*f_c-df
    samp_rate: samp_rate
    type: fir_filter_fff
    width: df/10
    win: window.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '2'
    high_cutoff_freq: 2*f_c + 2*df
    low_cutoff_freq: 2*(f_c) - 2*df
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: round(samp_rate/freq)*1000
    type: float
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '1'
    type: fcc
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    label1: Original
    label2: Harmonico
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@2
    label1: Original
    label2: Harmonico
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    label1: Original
    label2: Harmonico
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@3
    label1: Original
    label2: Demodulado
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tab@0
    size: round(samp_rate/freq)
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tab@1
    label1: Original
    label2: Harmonico
    nconnections: '2'
    size: round(samp_rate/freq)
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tab@2
    label1: Original
    label2: Harmonico
    nconnections: '2'
    size: round(samp_rate/freq)
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tab@0
    label1: Original
    label2: Modulado Indiretamente
    nconnections: '2'
    size: round(samp_rate/freq)
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tab@3
    label1: Original
    label2: Demodulado
    nconnections: '2'
    size: round(samp_rate/freq)*10
    srate: samp_rate
    type: float
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Indirect Method
    label1: HARMONICO 2
    label2: HARMONICO 3
    label3: Demodulado
    num_tabs: '4'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: NBFM
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: original
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: h2
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: h3
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: h2
  states: {}
- name: virtual_source_0_0_0_0_1_1_0
  id: virtual_source
  parameters:
    stream_id: NBFM
  states: {}
- name: virtual_source_0_0_0_0_1_1_0_0
  id: virtual_source
  parameters:
    stream_id: NBFM
  states: {}
- name: virtual_source_0_0_0_0_1_1_0_1
  id: virtual_source
  parameters:
    stream_id: NBFM
  states: {}
- name: virtual_source_0_0_0_0_1_1_0_1_0
  id: virtual_source
  parameters:
    stream_id: NBFM
  states: {}
- name: virtual_source_0_0_0_0_1_1_0_2
  id: virtual_source
  parameters:
    stream_id: NBFM
  states: {}
- name: virtual_source_0_0_0_0_1_1_0_2_0
  id: virtual_source
  parameters:
    stream_id: NBFM
  states: {}
- name: virtual_source_0_0_0_0_1_1_0_2_1
  id: virtual_source
  parameters:
    stream_id: NBFM
  states: {}
- name: virtual_source_0_0_0_0_1_1_0_2_1_0
  id: virtual_source
  parameters:
    stream_id: original
  states: {}
- name: virtual_source_0_0_0_0_1_1_0_2_1_0_0
  id: virtual_source
  parameters:
    stream_id: original
  states: {}
- name: virtual_source_0_0_0_0_1_1_0_3
  id: virtual_source
  parameters:
    stream_id: NBFM
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: h3
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: h3
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: original
  states: {state: disabled}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: original
  states: {state: disabled}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_pll_freqdet_cf_0, '0', qtgui_freq_sink_x_0_0_0_0_0, '1']
- [analog_pll_freqdet_cf_0, '0', qtgui_time_sink_x_0_0_0_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_sub_xx_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_1, '0', virtual_sink_1, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [band_pass_filter_0, '0', dc_blocker_xx_0_0, '0']
- [band_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0, '1']
- [band_pass_filter_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [band_pass_filter_0_0, '0', virtual_sink_1_0, '0']
- [blocks_complex_to_arg_0, '0', low_pass_filter_0, '0']
- [blocks_head_0, '0', band_pass_filter_0_0, '0']
- [blocks_head_0, '0', qtgui_freq_sink_x_0_0, '1']
- [blocks_head_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_head_0, '0', virtual_sink_1_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_const_vxx_0, '0', dc_blocker_xx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_0_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_multiply_xx_1, '0', qtgui_freq_sink_x_0_0_0_0, '1']
- [blocks_multiply_xx_1, '0', qtgui_time_sink_x_0_0_0_0, '1']
- [blocks_sub_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_sub_xx_0, '0', virtual_sink_0, '0']
- [blocks_throttle2_0, '0', blocks_head_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle2_0_0, '0', band_pass_filter_0, '0']
- [dc_blocker_xx_0, '0', qtgui_freq_sink_x_0_0, '1']
- [dc_blocker_xx_0, '0', qtgui_time_sink_x_0_0, '1']
- [dc_blocker_xx_0, '0', virtual_sink_1_0, '0']
- [dc_blocker_xx_0_0, '0', qtgui_freq_sink_x_0_0_0, '1']
- [dc_blocker_xx_0_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [dc_blocker_xx_0_0, '0', virtual_sink_1_0_0, '0']
- [fir_filter_xxx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [fir_filter_xxx_0, '0', analog_pll_freqdet_cf_0, '0']
- [fir_filter_xxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0_0_0_0, '1']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0_0_0_0, '1']
- [virtual_source_0, '0', blocks_multiply_xx_0_0_0, '1']
- [virtual_source_0_0_0_0_1_1_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0_0_0_0_1_1_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0_0_0_0_1_1_0_1, '0', blocks_multiply_xx_0_0, '0']
- [virtual_source_0_0_0_0_1_1_0_1, '0', blocks_multiply_xx_0_0, '1']
- [virtual_source_0_0_0_0_1_1_0_1_0, '0', blocks_multiply_xx_0_0_0, '0']
- [virtual_source_0_0_0_0_1_1_0_2, '0', qtgui_freq_sink_x_0_0_0, '0']
- [virtual_source_0_0_0_0_1_1_0_2_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [virtual_source_0_0_0_0_1_1_0_2_1, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [virtual_source_0_0_0_0_1_1_0_2_1_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [virtual_source_0_0_0_0_1_1_0_2_1_0_0, '0', qtgui_freq_sink_x_0_0_0_0_0, '0']
- [virtual_source_0_0_0_0_1_1_0_3, '0', qtgui_time_sink_x_0_0_0, '0']
- [virtual_source_1, '0', blocks_multiply_xx_1, '0']
- [virtual_source_2, '0', fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
