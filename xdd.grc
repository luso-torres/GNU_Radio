options:
  parameters:
    author: luso
    generate_options: qt_gui
    id: xdd
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\Downloads\aibecam.mp3
    repeat: 'True'
    type: float
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class ulaw_decoder(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          def __init__(self, mu=255):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='u-law Decoder',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.mu = mu

          def work(self, input_items, output_items):
              # Ensure input_items is properly indexed
              c0 = np.sign(input_items[0]) * (1/self.mu) * ((1 + self.mu)**np.abs(input_items[0]) - 1)
              output_items[0][:] = c0

              # Return the length of the output items produced
              return len(output_items[0])
    mu: '255'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '22000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '300'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: xdd
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: xdd
  states: {}

connections:
- [blocks_file_source_0, '0', audio_sink_0, '0']
- [blocks_file_source_0, '0', epy_block_0_0, '0']
- [blocks_file_source_0, '0', low_pass_filter_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_1, '0']
- [epy_block_0_0, '0', virtual_sink_0_0, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_0, '0', qtgui_time_sink_x_1, '1']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
