options:
  parameters:
    author: luso
    generate_options: qt_gui
    id: xdd
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: f_c
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\SDR-GNU\GNU_Radio\audio_converter\output.wav
    repeat: 'True'
    type: float
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '100000000'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class ulaw_decoder(gr.sync_block):
          def __init__(self, mu=255):
              gr.sync_block.__init__(
                  self,
                  name='u-law Decoder',
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.mu = mu

          def ulaw_decode(self, x):
              # Ensure x is within the valid range and handle NaN and Inf values
              x = np.nan_to_num(x, nan=0.0, posinf=1.0, neginf=-1.0)  # Replace NaN and Inf values
              x = np.clip(x, -1.0, 1.0)  # Ensure values are within the range [-1, 1]

              # Perform u-law decoding
              decoded = np.sign(x) * (1 / self.mu) * ((1 + self.mu) ** np.abs(x) - 1)
              decoded = np.nan_to_num(decoded, nan=0.0, posinf=1.0, neginf=-1.0)  # Replace NaN and Inf values again
              return decoded

          def normalize_audio(self, audio):
              max_val = np.max(np.abs(audio))
              if np.isfinite(max_val) and max_val > 0:
                  normalized_audio = audio / max_val
                  print("Normalization factor:", max_val)
                  return normalized_audio
              print("Invalid normalization factor:", max_val)
              return audio

          def work(self, input_items, output_items):
              # Apply u-law decoding
              decoded_signal = self.ulaw_decode(input_items[0])

              # Debug prints to check signal values before normalization
              print("Decoded Min:", np.min(decoded_signal), "Decoded Max:", np.max(decoded_signal))

              # Normalize the decoded signal
              normalized_signal = self.normalize_audio(decoded_signal)

              # Debug prints to check signal values after normalization
              print("Normalized Min:", np.min(normalized_signal), "Normalized Max:", np.max(normalized_signal))

              # Clip the values to avoid overflow
              output_items[0][:] = np.clip(normalized_signal, -1.0, 1.0)

              # Debug prints to check final signal values
              print("Output Min:", np.min(output_items[0]), "Output Max:", np.max(output_items[0]))

              return len(output_items[0])
    mu: '255'
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fff
    width: '100'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '22000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '300'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_audio
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: original
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: PCM
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: PCM
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: original
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: PCM
  states: {}

connections:
- [blocks_file_source_0, '0', epy_block_0_0, '0']
- [blocks_file_source_0, '0', low_pass_filter_0, '0']
- [blocks_file_source_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0_0, '0']
- [epy_block_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [filter_fft_low_pass_filter_0, '0', virtual_sink_0_0, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_1, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_1_0, '0', audio_sink_0, '0']
- [virtual_source_1_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
