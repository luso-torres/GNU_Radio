options:
  parameters:
    author: luso
    generate_options: qt_gui
    id: xdd
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.01'
    stop: '0.1'
    value: '0.01'
    widget: dial
  states: {}
- name: freq_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: 64 Hz
    orient: QtCore.Qt.Vertical
    start: '0'
    step: '.01'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: freq_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: 128 Hz
    orient: QtCore.Qt.Vertical
    start: '0'
    step: '.01'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: freq_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: 256 Hz
    start: '0'
    step: '0.010'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: freq_3
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,1
    label: 512 Hz
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: freq_4
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,5,1,1
    label: 1000 Hz
    start: '0'
    step: '.01'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: freq_5
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: 2000 Hz
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: freq_6
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: 4000 Hz
    start: '0'
    step: '.01'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: freq_7
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: 8000 Hz
    start: '0'
    step: '.01'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: freq_8
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3,1,1
    label: 16000 Hz
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: freq_9
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: 32 Hz
    orient: QtCore.Qt.Vertical
    start: '0'
    step: '.01'
    stop: '1'
    value: '0.1'
    widget: dial
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: E:\Repositorios\GNU_Radio\audio_converter\output.wav
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-.1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Volume
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import scipy.signal as signal

      class FrequencyBandFilter(gr.sync_block):
          def __init__(self, filter_length=101, sample_rate=32000, gains=None):
              gr.sync_block.__init__(self,
                                     name="FrequencyBandFilter",
                                     in_sig=[np.float32],
                                     out_sig=[np.float32])

              self.filter_length = filter_length
              self.sample_rate = sample_rate

              # Frequências centrais das bandas
              self.freqs = np.array([32, 64, 128, 256, 512, 1000, 2000, 4000, 8000, 16000])

              # Cálculo das frequências de corte
              self.cutoff_freqs = [(self.freqs[i] / np.sqrt(2), self.freqs[i] * np.sqrt(2)) for i in range(len(self.freqs))]

              # Verifica se a lista de ganhos foi fornecida, caso contrário, define todos como 1 (sem alteração)
              if gains is None:
                  gains = np.ones(len(self.freqs))

              # Normaliza os ganhos para que a soma dos valores não ultrapasse 1
              self.gains = np.array(gains)
              self.gains /= np.sum(self.gains)  # Ajusta proporcionalmente para garantir uma soma ≤ 1

              # Criando filtros FIR usando a janela de Hamming
              self.filters = []
              for i, (low, high) in enumerate(self.cutoff_freqs):
                  if low < 1:
                      low = 1  # Evita frequência 0 Hz
                  if high >= self.sample_rate / 2:
                      high = self.sample_rate / 2 - 1  # Limite Nyquist

                  fir_coeffs = signal.firwin(self.filter_length, [low, high], pass_zero=False, fs=self.sample_rate, window="hamming")
                  fir_coeffs /= np.sum(fir_coeffs)  # Normaliza os coeficientes
                  self.filters.append(fir_coeffs * self.gains[i])  # Aplica ganho ajustado

          def work(self, input_items, output_items):
              output_signal = np.zeros_like(input_items[0])

              # Aplicando filtros com ganhos ajustados
              for fir_coeffs in self.filters:
                  filtered_signal = signal.lfilter(fir_coeffs, 1.0, input_items[0])
                  output_signal += filtered_signal  # Somando sinais filtrados

              output_items[0][:] = output_signal
              return len(output_items[0])
    filter_length: '1'
    gains: '[freq_0,freq_9, freq_1,freq_2, freq_3, freq_4, freq_5, freq_6, freq_7,freq_8]'
    sample_rate: samp_rate
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class ulaw_decoder(gr.sync_block):
          def __init__(self, mu=255):
              gr.sync_block.__init__(
                  self,
                  name='u-law Decoder',
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.mu = mu

          def ulaw_decode(self, x):
              # Ensure x is within the valid range and handle NaN and Inf values
              x = np.nan_to_num(x, nan=0.0, posinf=1.0, neginf=-1.0)  # Replace NaN and Inf values
              x = np.clip(x, -1.0, 1.0)  # Ensure values are within the range [-1, 1]

              # Perform u-law decoding
              decoded = np.sign(x) * (1 / self.mu) * ((1 + self.mu) ** np.abs(x) - 1)
              decoded = np.nan_to_num(decoded, nan=0.0, posinf=1.0, neginf=-1.0)  # Replace NaN and Inf values again
              return decoded

          def normalize_audio(self, audio):
              max_val = np.max(np.abs(audio))
              if np.isfinite(max_val) and max_val > 0:
                  normalized_audio = audio / max_val
                  print("Normalization factor:", max_val)
                  return normalized_audio
              print("Invalid normalization factor:", max_val)
              return audio

          def work(self, input_items, output_items):
              # Apply u-law decoding
              decoded_signal = self.ulaw_decode(input_items[0])

              # Debug prints to check signal values before normalization
              print("Decoded Min:", np.min(decoded_signal), "Decoded Max:", np.max(decoded_signal))

              # Normalize the decoded signal
              normalized_signal = self.normalize_audio(decoded_signal)

              # Debug prints to check signal values after normalization
              print("Normalized Min:", np.min(normalized_signal), "Normalized Max:", np.max(normalized_signal))

              # Clip the values to avoid overflow
              output_items[0][:] = np.clip(normalized_signal, -1.0, 1.0)

              # Debug prints to check final signal values
              print("Output Min:", np.min(output_items[0]), "Output Max:", np.max(output_items[0]))

              return len(output_items[0])
    mu: '255'
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fff
    width: '100'
    win: window.WIN_HANN
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '22000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '300'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.02'
    decim: '1'
    gain: '1'
    ntaps: 11*samp_rate
    samp_rate: samp_rate
    sym_rate: '1.0'
    type: fir_filter_fff
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: original
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: PCM
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: PCM
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: PCM
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: original
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: PCM
  states: {}

connections:
- [blocks_file_source_0, '0', epy_block_0_0, '0']
- [blocks_file_source_0, '0', low_pass_filter_0, '0']
- [blocks_file_source_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [epy_block_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_0_0, '0', epy_block_0, '0']
- [epy_block_0_0, '0', root_raised_cosine_filter_0, '0']
- [filter_fft_low_pass_filter_0, '0', virtual_sink_0_0, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [root_raised_cosine_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_0_0, '0', qtgui_time_sink_x_1, '1']
- [virtual_source_1, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_1_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [virtual_source_1_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
